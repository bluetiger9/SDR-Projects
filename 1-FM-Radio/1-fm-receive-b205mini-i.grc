options:
  parameters:
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    min_len: '400'
    orient: Qt.Horizontal
    start: 0.01e6
    step: 0.01e6
    stop: 10e6
    value: 2e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '400'
    orient: Qt.Horizontal
    start: 88.0e6
    step: 0.1e6
    stop: 106.0e6
    value: 95.1e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    min_len: '400'
    orient: Qt.Horizontal
    start: '-10'
    step: '0.1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.96e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    min_len: '400'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: 16e3
    audio_stop: 20e3
    chan_rate: 192e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth
    center_freq0: freq
    clock_source0: internal
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
