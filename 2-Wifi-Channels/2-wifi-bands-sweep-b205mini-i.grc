options:
  parameters:
    generate_options: qt_gui
    id: wifi_bands
    output_language: python
    title: Wifi Bands
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: py_module.sweeper(func_probe)
  states: {}
- name: freq_center
  id: variable
  parameters:
    value: freq_start + (freq_end - freq_start) / 2
  states: {}
- name: freq_end
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: freq_lbl
  id: variable_qtgui_label
  parameters:
    label: Frequency
    type: real
    value: freq
  states: {}
- name: freq_start
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: func_probe
  id: variable_function_probe
  parameters:
    block_id: py_module
    function_name: sweeper
    poll_rate: '10'
    value: '0'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: step
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Freq offset
    amp: '1'
    freq: freq - freq_center
    offset: '0'
    phase: '0'
    samp_rate: 100e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: py_module
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      step = 50e6
      freq_start = 2.4e9 + step / 2
      freq_end = 2.5e9
      f = freq_start

      def sweeper(prob_lvl = None):
          global freq_start, freq_end, freq, f
          print("Call Sweeper!")
          if prob_lvl:
              f += step
          if f > freq_end: f = freq_start
          return f
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: freq_end - freq_start
    ctrlpanel: 'True'
    fc: freq_center
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: freq_end - freq_start
    fc: freq_center
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth
    center_freq0: freq
    clock_rate: 30.72e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '40'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
